# Keil uVision project int_tutorial.uvprojx, settings and files
target IntApp (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x6000) IRAM2(0x1FFFE000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: int_tutorial
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  group src
    ./: main.c leds.c buttons.c lptimer.c lowpower.c
  group ::Device
    RTE/Device/MKL46Z256xxx4/: startup_MKL46Z4.s system_MKL46Z4.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
