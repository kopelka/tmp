# Keil uVision project project.uvprojx, settings and files
target CMSIS-DAP (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group src
    ./: main.c leds.c slcd.c buttons.c extra.c
software components: CMSIS:CORE 4.2.0, Device:Startup 1.0.0
